v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/foss/designs/IHP-Open-PDK/ihp-sg13g2/libs.tech/xschem/sg13g2_pr/npn13G2.sym} 200 70 0 1 {name=Q1
model=npn13G2
spiceprefix=X
Nx=1
}
C {/foss/designs/IHP-Open-PDK/ihp-sg13g2/libs.tech/xschem/sg13g2_pr/npn13G2.sym} 40 70 0 0 {name=Q2
model=npn13G2
spiceprefix=X
Nx=1
}
